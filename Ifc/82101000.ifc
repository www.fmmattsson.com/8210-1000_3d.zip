Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Roger_prio1\Arbetsmapp\82101000\AutoCAD Architecture\82101000.ifc
Time: 2014-02-27T09:12:10
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 82101000
LongName: 82101000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 82101000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 82101000, BUILDINGELEMENTPROXY(1)
In: 82101000
Description: FM Mattsson 82101000, Safety mixer f/ Shower 9000E II 160 c/c, chrome
